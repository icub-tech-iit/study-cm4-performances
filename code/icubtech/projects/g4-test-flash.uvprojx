# Keil uVision project g4-test-flash.uvprojx, settings and files
target STM32G474E-EVAL (6190000::V6.19::.\armclang-r6p19-00rel0)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32G474xx,USE_HAL_DRIVER,USE_STM32G474E_EVAL
  c misc: -DEMBOT_APP_SCOPE_core -DSTM32HAL_STM32G4
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32G474E-EVAL;../../../../Drivers/BSP/Components/Common;..\..\..\..\..\icubtech\testcode;..\..\..\..\..\icubtech\utils\embot\app;..\..\..\..\..\icubtech\utils\embot\core;..\..\..\..\..\icubtech\utils\embot\hw;..\..\..\..\..\icubtech\utils\embot\tools;..\..\..\..\..\icubtech\utils\eventviewer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c hx8347d_reg.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../Drivers/BSP/Components/mt25ql512abb/: mt25ql512abb.c
    ../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/STM32G474E-EVAL
    ../../../../Drivers/BSP/STM32G474E-EVAL/: stm32g474e_eval.c stm32g474e_eval_audio.c stm32g474e_eval_bus.c stm32g474e_eval_env_sensor.c stm32g474e_eval_io.c stm32g474e_eval_lcd.c stm32g474e_eval_qspi.c stm32g474e_eval_sd.c stm32g474e_eval_smartcard.c stm32g474e_eval_sram.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_fmac.c stm32g4xx_hal_gpio.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_i2s.c stm32g4xx_hal_irda.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_lptim.c stm32g4xx_hal_msp_template.c stm32g4xx_hal_nand.c stm32g4xx_hal_nor.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_sai_ex.c stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_smbus.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_timebase_tim_template.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_wwdg.c stm32g4xx_ll_fmc.c stm32g4xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32g474xx.s
  group Example/User
    ../Src/: main.c stm32g4xx_it.c
  group cm4-test-main
    ../../../../../icubtech/testmain/: g4main.c
  group cm4-test-code
    ../../../../../icubtech/testcode/: testcode.cpp
  group cm4-utils
    ../../../../../icubtech/utils/embot/app/: embot_app_scope.cpp
    ../../../../../icubtech/utils/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
    ../../../../../icubtech/utils/embot/tools/: embot_tools.cpp
    ../../../../../icubtech/utils/embot/hw/: embot_hw_sys.cpp
    ../../../../../icubtech/utils/eventviewer/: eventviewer.c
  group cm4-utils-zero-optimization
    ../../../../../icubtech/utils/embot/hw/: embot_hw_lowlevel.cpp
software components: CMSIS:CORE 5.3.0
