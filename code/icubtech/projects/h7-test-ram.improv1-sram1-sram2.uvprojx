# Keil uVision project h7-test-ram.improv1-sram1-sram2.uvprojx, settings and files
target STM32H745I_DISCO_CM4 (6190000::V6.19::.\armclang-r6p19-00rel0)
  device: STM32H745XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IROM(0x08100000-0x81FFFFF) IRAM(0x10000000-0x10047FFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32H745I_DISCO_CM4
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER, STM32H745xx,USE_STM32H745I_DISCO,CORE_CM4
  c misc: -DEMBOT_APP_SCOPE_core -DSTM32HAL_STM32H7
  c include: ../Common/Inc;../CM4/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32H745I-DISCO;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Fonts;../../../../../Utilities/CPU;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;.;..\..\..\..\..\..\icubtech\testcode;..\..\..\..\..\..\icubtech\utils\embot\core;..\..\..\..\..\..\icubtech\utils\embot\app;..\..\..\..\..\..\icubtech\utils\embot\tools;..\..\..\..\..\..\icubtech\utils\embot\hw;..\..\..\..\..\..\icubtech\utils\eventviewer
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x30020000 size 0x20000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
    ../../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/BSP/STM32H745I_DISCO
    ../../../../../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery_bus.c stm32h745i_discovery_lcd.c stm32h745i_discovery_mmc.c stm32h745i_discovery_qspi.c stm32h745i_discovery_sdram.c stm32h745i_discovery_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32h745xx.s
    ./: cm4_code.s
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group cm4-test-main
    ../../../../../../icubtech/testmain/: h7-ram-main.c
  group cm4-test-code
    ../../../../../../icubtech/testcode/: testcode.cpp
  group cm4-utils
    ../../../../../../icubtech/utils/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
    ../../../../../../icubtech/utils/embot/app/: embot_app_scope.cpp
    ../../../../../../icubtech/utils/embot/hw/: embot_hw_sys.cpp
    ../../../../../../icubtech/utils/embot/tools/: embot_tools.cpp
    ../../../../../../icubtech/utils/eventviewer/: eventviewer.c
  group cm4-utils-zero-optimization
    ../../../../../../icubtech/utils/embot/hw/: embot_hw_lowlevel.cpp
target STM32H745I_DISCO_CM7 (6190000::V6.19::.\armclang-r6p19-00rel0)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H745I_DISCO_CM7 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32H745xx, USE_STM32H745I_DISCO,CORE_CM7
  c include: ../Common/Inc;../CM7/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32H745I-DISCO;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Fonts;../../../../../Utilities/CPU;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  link misc: --keep=cm4_code
software components: CMSIS:CORE 5.2.0
